# Repository rosmo-robot/CrowBot

File README.md:

# CrowBot
Design files for Elecrow CrowBot

CERN-OHL-P

Crowbolt in [Altium viewer](https://365.altium.com/files/6BD3D0E1-E369-48C4-9C85-A43504ED84B5)

[Wiki page with example code](https://www.elecrow.com/wiki/index.php?title=CrowBot-BOLT_Programmable_Smart_Robot_Car_STEAM_Robot_Kit)

## EAGLE design Hardware/Eagle/CrowBot -V1.4-20220909.brd

Parts:
B1: MLT-8530
C1, C45: 10uF; DISCRETE_C0603
C2, C10, C20, C22, C23, C28, C31: 100nF; DISCRETE_C0603
C3, C4, C27, C29, C30, C38, C39, C44: 1uF; DISCRETE_C0603
C5, C6, C8, C13, C15, C17, C32, C33, C34, C35, C36, C37, C48, C50: 1uF; 0603
C7, C12, C16, C19, C21, C42, C43, C47, C49, C52: 22uF; 0805
C9, C18, C26: 100nF; 0603
C11: 4.7uF; 0603
C24, C25: 20pF; 0603
C40, C41: 220UF/16V; CAP_220UF_SMD_6.3*5.4MM
C54: 100uF; CAP-100UF-SMD-6.3*4.5MM
D1, D2: LIGHT-PD-F5MM
D3: S2M/SMB; 214AB
D5: 1N5819WS; SOD-323
D6: SS34B/SMB; 214AB
J1: TYPEC-3.0-16P-SMD
J2: PH2.0_2P
J3: HEADER-4P-80/40MIL; 4P-2.54-80/40MIL
J4: TSOP382; 3P-2.54-4.8X5X6.95H
J5, J6: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
J7, J8: 1.25MM-2PIN; CROWBOT-V1.0库_1.25MM-2PIN
K1: SWITCH-8.96.94.7MM; SWITCH-8.9*6.9*4.7MM
K2: KEY_BM_4PIN
K3, K4: CROWBOT-V1.1库_KEY_EN_2PIN_B/W
L1, L2, L3, L4: 5.6UH; CD54
LED1, LED5, LED6: BLUE; DISCRETE_LED-0603
LED4: LED_BOTH_RED_BLUE; LED_BOTH_RED_BLUE_SMD_1.6*1.6*0.6MM
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15, P16, P17, P18, P19, P20, P21, P22, P23, P24, P25, P26: PADPAD-1.0MM; PAD-1.0MM
Q1, Q3, Q6, Q7, Q8, Q11: 2N7002; SOT23
Q2, Q9, Q10: S9013; SOT23@1
Q4, Q5: 2N7002/NC; SOT23
R1, R5, R15, R17, R21, R24, R29, R47, R53: 10K; DISCRETE_R0603
R2, R52: 0R; DISCRETE_R0603
R3, R7: 0R; 0603_S
R4, R48, R56: 10K; R0603
R6: 73.2K; DISCRETE_R0603
R8, R9, R71, R72: 22R; DISCRETE_R0603
R10, R11, R13, R14, R50, R51: 5.1K; DISCRETE_R0603
R16, R20, R23: 45.3K; DISCRETE_R0603
R18: 20K; DISCRETE_R0603
R25, R26: 10K; 0603_S
R27, R28, R35, R36, R37, R38, R39, R40, R58, R59: 4.7K; DISCRETE_R0603
R30, R31, R33, R34: 4.7K/NC; DISCRETE_R0603
R32, R54, R73, R74, R75: 1K; DISCRETE_R0603
R41, R43: 300R; 0603_S
R42, R44: 24K; 0603_S
R45: 5.1R; R0603
R46: 2K; DISCRETE_R0603
R49: 24K; R0603
R57: 21K; R0603
RGB1, RGB2, RGB3, RGB4: LED-RGB-4P-2427; LED-RGB-4P-SMD-2427
S1: RPR220（右边）; 4P-6.4X4.9X6.5H
S2: RPR220(左边）; 4P-6.4X4.9X6.5H
U1, U9, U10: HM3416H; A_XBJ_SOT23-5
U2: HM1548C; A_XBJ_SOT23-6
U3: ESP32-WROVER-B
U4, U5: L9110S/SOP8
U6: CH340G; SOP-16
U7: ME321AM5G-SOT23-5
U8: AO4407A_PMOS; SOP8
X1: 12Mhz,20pF,10ppm; SMD3225

Connections:
3V3: C7.2, C8.2, C9.2, C10.2, C15.2, C26.1, C27.2, C28.2, C31.2, C43.2, C44.2, C45.2, J4.3 (VS), L1.1, L4.2, P2.P$1, Q1.1 (G), Q3.1 (G), Q4.1 (G), Q5.1 (G), Q6.1 (G), Q7.1 (G), Q8.1 (G), Q11.3 (D), R1.1, R10.2, R11.2, R20.1, R25.2, R26.2, R27.1, R29.1, R30.1, R32.2, R33.1, R35.1, R37.1, R39.1, R45.1, R48.1, R51.2, R54.2, R58.1, U2.4 (4-SHDN), U2.5 (5-VIN), U6.4 (V3), U6.16 (VCC), U7.5 (+VS)
3V3_MCU: C1.2, C2.2, C29.2, C30.2, C49.2, C50.2, C54.1+, L3.2, R4.1, R23.1, R42.1, R44.1, S1.1 (A), S2.1 (A), U3.2 (VDD33)
3V3_MOTOR: C12.2, C13.2, C19.2, C20.2, C21.2, C22.2, C40.1+, C41.1+, L2.2, R16.1, U4.2 (VCC), U4.3 (VCC1), U5.2 (VCC), U5.3 (VCC1)
5V: C3.2, C4.2, C16.2, C17.2, C18.2, C38.2, C39.2, D6.2 (-), J3.1, J5.3, J6.3, P1.P$1, P5.P$1, P22.P$1, P25.P$1, R6.1, R28.1, R31.1, R34.1, R36.1, R38.1, R40.1, R59.1, RGB1.4_VCC (4-VCC), RGB2.4_VCC (4-VCC), RGB3.4_VCC (4-VCC), RGB4.4_VCC (4-VCC)
BAT+: J2.1, P4.P$1, U8.P$5 (5_D), U8.P$6 (6_D), U8.P$7 (7_D), U8.P$8 (8_D)
D+: J1.A6 (DP1), J1.B6 (DP2), P11.P$1, R9.1
D-: J1.A7 (DN1), J1.B7 (DN2), P12.P$1, R8.1
DTR: Q10.2 (E), R75.2, U6.13 (DTR#)
EN: C11.1, K4.2, Q9.3 (C), R4.2, U3.3 (EN)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C34.1, C35.1, C36.1, C38.1, C39.1, C40.2-, C41.2-, C42.1, C43.1, C44.1, C45.1, C47.1, C48.1, C49.1, C50.1, C52.1, C54.2-, D1.2, D2.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.P$1, J1.P$2, J2.2, J2.3, J2.4, J3.4, J4.2 (GND), J5.4, J5.SS1, J5.SS2, J6.4, J6.SS1, J6.SS2, J7.3, J7.4, J8.3, J8.4, K2.2, K2.4, K3.1, K4.1, LED4.2, P13.P$1, P16.P$1, P20.P$1, P21.P$1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
IO0_DOWNLOAD: Q10.3 (C), U3.25 (GPIO0,ADC2_CH1,TOUCH1,RTC_GPIO11,CLK_OU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)
IO4_LED: Q1.2 (S), R58.2, U3.26 (GPIO4,ADC2_CH0,TOUCH0,RTC_GPIO10,HSPIHD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)
IO4_PORT_IN: J5.2, P26.P$1, Q1.3 (D), R59.2
IO5_WIFI: K2.3, LED6.-, R25.1, U3.29 (GPIO5,VSPICS0,HS1_DATA6,EMAC_RX_CLK)
IO12_M1_PWM+: U3.14 (GPIO12,ADC2_CH5,TOUCH5,RTC_GPIO15,MTDI,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), U4.7 (IB)
IO13_M1_PWM-: U3.16 (GPIO13,ADC2_CH4,TOUCH4,RTC_GPIO14,MTCK,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), U4.6 (IA)
IO14_M2_PWM+: U3.13 (GPIO14,ADC2_CH6,TOUCH6,RTC_GPIO16,MTMS,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), U5.7 (IB)
IO15_M2_PWM-: U3.23 (GPIO15,ADC2_CH3,TOUCH3,MTDO,HSPICS0,RTC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), U5.6 (IA)
IO18_BUTTON: C23.2, K3.2, R1.2, U3.30 (GPIO18,VSPICLK,HS1_DATA7)
IO19_IR: J4.1 (OUT), R29.2, U3.31 (GPIO19,VSPIQ,U0CTS,EMAC_TXD0)
IO21_SCL: Q6.2 (S), R37.2, U3.33 (GPIO21,VSPIHD,EMAC_TX_EN)
IO21_SCL_IN: J6.1, P19.P$1, Q6.3 (D), R38.2
IO22_SDA: Q7.2 (S), R39.2, U3.36 (GPIO22,VSPIWP,U0RTS,EMAC_TXD1)
IO22_SDA_IN: J6.2, P18.P$1, Q7.3 (D), R40.2
IO23_PORT: Q8.2 (S), R35.2, U3.37 (GPIO23,VSPID,HS1_STROBE)
IO23_PORT_IN: J5.1, P17.P$1, Q8.3 (D), R36.2
IO25_4RGB: Q3.2 (S), R27.2, U3.10 (GPIO25,DAC_1,ADC2_CH8,RTC_GPIO6,EMAC_RX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)
IO25_4RGB_IN: Q3.3 (D), R28.2, RGB1.3_DIN (3-DIN)
IO26_UT_RGB: Q4.2 (S), R2.1, R30.2, U3.11 (GPIO26,DAC_2,ADC2_CH9,RTC_GPIO7,EMAC_RX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)
IO26_UT_RGB_IN: J3.2, P15.P$1, Q4.3 (D), R2.2, R31.2
IO27_UT_IO: Q5.2 (S), R33.2, R52.1, U3.12 (GPIO27,ADC2_CH7,TOUCH7,RTC_GPIO17,EMAC_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)
IO27_UT_IO_IN: J3.3, P14.P$1, Q5.3 (D), R34.2, R52.2
IO32_BT: K2.1, LED5.-, R26.1, U3.8 (GPIO32,XTAL_32K_P,ADC1_CH4,TOUCH9,RTC_G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)
IO33_BUZZER: R46.1, R47.2, U3.9 (GPIO33,XTAL_32K_N,ADC1_CH5,TOUCH8,RTC_G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)
IO34_LIGHT: D2.1, R11.1, U3.6 (GPIO34,ADC1_CH6,RTC_GPIO4)
IO35_LIGHT: D1.1, R10.1, U3.7 (GPIO35,ADC1_CH7,RTC_GPIO5)
IO36_TRACK: R7.2, U3.4 (SENSOR_VP,GPIO36,ADC1_CH0,RTC_GPIO0)
IO39_TRACK: R3.2, U3.5 (SENSOR_VN,GPIO39,ADC1_CH3,RTC_GPIO3)
unnamed: R23.2, R24.1, U10.5 (FB)
unnamed: R16.2, R17.1, U9.5 (FB)
unnamed: L2.1, U9.3 (SW)
unnamed: R56.2, R57.1, U7.1 (+IN)
unnamed: B1.2 (-), D5.2 (+), Q2.3 (C)
unnamed: R5.1, R6.2, U2.3 (3-FB)
unnamed: LED5.+, R32.1
unnamed: R18.2, U2.6 (6-NC)
unnamed: R53.1, U3.24 (GPIO2,ADC2_CH2,TOUCH2,RTC_GPIO12,HSPIWP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)
unnamed: J1.A5 (CC1), R13.2
unnamed: R41.2, S1.2 (C)
unnamed: L4.1, U1.3 (SW)
unnamed: B1.1 (+), D5.1 (-), R45.2
unnamed: R7.1, R42.2, S1.3 (EM)
unnamed: D6.1 (+), L1.2, U2.1 (1-SW)
unnamed: RGB1.1_DOUT (1-DOUT), RGB2.3_DIN (3-DIN)
unnamed: Q11.2 (S), R73.2
unnamed: R3.1, R44.2, S2.3 (EM)
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: J1.B5 (CC2), R14.1
unnamed: R43.2, S2.2 (C)
unnamed: L3.1, U10.3 (SW)
unnamed: LED6.+, R54.1
unnamed: LED4.1, R50.2
unnamed: RGB2.1_DOUT (1-DOUT), RGB3.3_DIN (3-DIN)
unnamed: LED4.3, R51.1
unnamed: RGB3.1_DOUT (1-DOUT), RGB4.3_DIN (3-DIN)
unnamed: D3.2 (-), K1.1, U8.P$1 (1_S), U8.P$2 (2_S), U8.P$3 (3_S)
unnamed: Q9.1 (B), R75.1
unnamed: Q2.1 (B), R46.2
unnamed: Q10.1 (B), R74.1
unnamed: LED1.+, R73.1
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
OUT1+: C33.2, C34.2, J7.2, P6.P$1, U4.1 (OA)
OUT1-: C32.2, C33.1, J7.1+, P7.P$1, U4.4 (OB)
OUT2+: C35.2, C37.2, J8.1+, P8.P$1, U5.1 (OA)
OUT2-: C36.2, C37.1, J8.2, P9.P$1, U5.4 (OB)
RTS: Q9.2 (E), R74.2, U6.14 (RTS#)
UART0_RXD0: R72.1, U3.34 (RXD0,GPIO3,CLK_OUT2)
UART0_TXD0: LED1.-, R71.1, U3.35 (TXD0,GPIO1,CLK_OUT3,EMAC_RXD2)
USB_D+: R9.2, U6.5 (UD+)
USB_D-: R8.2, U6.6 (UD-)
VBUS: D3.1 (+), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), P10.P$1, Q11.1 (G), R15.2, U8.P$4 (4_G)
VIN: C5.2, C6.2, C42.2, C47.2, C48.2, C52.2, K1.2, P3.P$1, R56.1, U1.1 (EN), U1.4 (VIN), U9.1 (EN), U9.4 (VIN), U10.1 (EN), U10.4 (VIN)
VIN_2: R48.2, R49.1, U7.3 (-IN)
VOUT: LED4.4, R50.1, U7.4 (OUT)
XI: C24.2, U6.7 (XI), X1.1 (XIN)
XO: C25.2, U6.8 (XO), X1.3 (XOUT)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
模块3.3V电源
Vout=0.6*(R6/R5 +1)=5V
模块5V电源电路
红外接收头
超声波传感器
蜂鸣器
循迹模块
4个RGB灯
I2C Port
D Port
光敏传感器
电机3.3V降压电路
电机驱动
主控 ESP32-WROVER-B
USB
电池及控制电路
电平转换
IO0: 低电平：下载启动 高电平：SPI启动
下载闪烁灯
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
WiFi和BT开关
定值2.3V
5V定值2.5V 4.6V时为2.3V， 4.7V为红色，4.8V为蓝色
主控3.3V降压电路

Board: 2 copper layers, 60.4 x 112.5 mm, 194 parts (114 on the bottom side), 87 nets.

Other parts of the board:
U$3: SIG_TOP
U$4: SIG_BOTTOM
U$30: ELECROW-NEW
U$56: OSHW_FILLX200_NOTEXT

## Commit log

2023-02-27 CERN-OHL-P
    As agreed by Elecrow https://ohwr.org/cern_ohl_p_v2.txt
2023-02-27 Kicad6 Project
2023-02-27 Create images
2023-02-27 Original Eagle files
